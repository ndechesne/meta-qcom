PACKAGE_INSTALL += " \
    coreutils \
    cryptsetup \
    devmem2 \
    iozone3 \
    kexec \
    makedumpfile \
    util-linux \
"
